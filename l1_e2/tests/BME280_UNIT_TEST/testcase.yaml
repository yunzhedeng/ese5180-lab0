## l1_e2/tests/BME280_UNIT_TEST/testcase.yaml
```yaml
tests:
  bme280.sanity:
    platform_allow:
      - qemu_cortex_m3
    tags:
      - bme280
      - unit
    harness: ztest
```
